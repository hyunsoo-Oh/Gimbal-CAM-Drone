# Repository hyunsoo-Oh/Gimbal-CAM-Drone

## KiCad design Schematic/bms/bms/bms.kicad_pcb

Parts:
C1, C2, C3, C5: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C6, C7: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C8, C10: 47uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C9: 33pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C11, C12: 33uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C13: 100uF; CP_Elec_6.3x5.9
D1, D2: LED_Green; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D3, D4: SS34; D_SMA_Handsoldering
J1: XT60-M; XT60-M_1x02_P7.20mm_Vertical; PARTREV V1.2
J2, J3: 5V; SolderWirePad_1x01_SMD_2x4mm
J4, J5, J11, J12, J13, J14, J15: GND; SolderWirePad_1x01_SMD_2x4mm
J6, J7, J8, J9, J10: 3.3V; SolderWirePad_1x01_SMD_2x4mm
J16: Battery Charge; TerminalBlock_MaiXu_MX126-5.0-02P_1x02_P5.00mm
J17: M3 Vcc; SolderWirePad_1x01_SMD_4x8mm
J18: M3 GND; SolderWirePad_1x01_SMD_4x8mm
J19: M4 Vcc; SolderWirePad_1x01_SMD_4x8mm
J20: M4 GND; SolderWirePad_1x01_SMD_4x8mm
L1: 4.7uH; L_7.3x7.3_H3.5
R1, R4: 2.2k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R3, R6, R8: 0; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5: 31.6k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7, R11: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R9: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R10: 4.32k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R12: 18.6k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R13: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: LMR51450SDRRR; CONV_LMR51450SDRRR; PARTREV December 2022
U2: TPSM53602RDA; Texas_B3QFN-14-1EP_5x5.5mm_P0.65mm_ThermalVia

Connections:
+3V3: C8.2, C10.2, D4.2 (A), J6.1, J7.1, J8.1, J9.1, J10.1, R4.1, R9.1, U2.7 (VOUT), U2.8 (VOUT)
+5V: C11.1, C12.1, C13.1, J2.1, J3.1, L1.2, R1.1, R11.1, R13.1
GND: R2.1, R3.1
unnamed: C9.1, R13.2
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R4.2
unnamed: C7.2, D3.2 (A), L1.1, U1.1 (SW), U1.2 (SW), U1.3 (SW)
unnamed: C7.1, U1.4 (BOOT)
unnamed: R11.2, R12.1, U1.7 (FB)
unnamed: R5.1, U1.6 (RT)
unnamed: R9.2, R10.1, U2.9 (FB)
unnamed: R7.2, U2.6 (PGOOD)
unnamed: R7.1, U2.13 (V5V)
PACK-: J16.2, J18.1, J20.1; also elsewhere on the board
PGND_BAT: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C11.2, C12.2, C13.2, J1.N (NEG), R2.2, R6.1, R8.2, U1.13 (PGND), U2.3 (PGND), U2.10 (PGND), U2.11 (PGND), U2.15 (PGND); also elsewhere on the board
SGND: C8.1, C9.2, C10.1, D1.1 (K), D2.1 (K), J4.1, J5.1, J11.1, J12.1, J13.1, J14.1, J15.1, R3.2, R5.2, R6.2, R8.1, R10.2, R12.2, U1.8 (AGND), U2.12 (AGND); also elsewhere on the board
VBAT: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, D3.1 (K), D4.1 (K), J1.P (POS), J16.1, J17.1, J19.1, U1.9 (EN), U1.10 (VIN), U1.11 (VIN), U1.12 (VIN), U2.1 (VIN), U2.2 (EN), U2.14 (VIN); also elsewhere on the board

Notes on the sheet:
ESC 패드
충전 패드
5V Buck
3.3V Buck
스위칭 주파수 선택 기준
Net Tie
동기식 Buck 5A Synchronous Step-Down DC/DC Converter
전원 확인용 LED
1. 낮은 주파수 (200k~400kHz) - 장점: 스위칭 손실이 적어 효율↑, 발열↓ - 단점: 인덕터와 커패시터 값이 커져서 부품 크기↑ 2. 중간 주파수 (500kHz, 기본값) - 장점: 효율과 크기 사이의 균형 - TI 기본 권장값 3. 높은 주파수 (800kHz~1MHz) - 장점: 인덕터·커패시터 값이 작아져서 PCB 크기↓ - 단점: 스위칭 손실↑, 발열↑, 효율↓

Parts:
C14, C15, C16, C17, C18: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C19, C20, C21, C22: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D5, D6: 1.25V; D_SOD-123
J21, J22: 5267-05A-X; Molex_SPOX_5267-05A_1x05_P2.50mm_Vertical
Q1: PMOS; SOT-323_SC-70_Handsoldering
Q2: CSD17581Q3A; VSON-8_3.3x3.3mm_P0.65mm_NexFET
R14, R15, R16, R17, R18, R19, R21, R23: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R20: Shunt 0.5m; R_Shunt_Vishay_WSR2_WSR3
R22, R27: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R24: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R25, R26: 1M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R28, R29: 4.7k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TH1: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U3: BQ76920PW; TSSOP-20_4.4x6.5mm_P0.65mm

Connections:
/BQ76920_BMS/GPIO: J22.4, U3.20 (ALERT)
/BQ76920_BMS/REGOUT: R28.1, R29.1, U3.8 (REGOUT)
/BQ76920_BMS/SCL: J22.2, R28.2, U3.5 (SCL)
/BQ76920_BMS/SDA: J22.3, R29.2, U3.4 (SDA)
/BQ76920_BMS/VC0: C18.1, R18.2, U3.17 (VC0)
/BQ76920_BMS/VC1: C16.2, C17.1, R17.2, R27.1, U3.16 (VC1)
/BQ76920_BMS/VC2: C15.2, C16.1, R16.2, U3.15 (VC2)
/BQ76920_BMS/VC3_4: C14.2, C15.1, R15.2, U3.13 (VC4), U3.14 (VC3)
/BQ76920_BMS/VC5: C14.1, R14.2, U3.12 (VC5)
unnamed: D5.1 (K), R22.1, R23.1
unnamed: D6.2 (A), R24.2, R25.1
unnamed: D6.1 (K), Q2.4 (G), R25.2, R26.2
unnamed: J21.2, R17.1
unnamed: J21.3, R16.1
unnamed: J21.4, R15.1
unnamed: Q1.1 (D), R24.1
unnamed: Q1.3 (S), U3.2 (CHG)
unnamed: Q2.5 (D), R20.1, R21.1
unnamed: R23.2, U3.9 (REGSRC), U3.10 (BAT)
unnamed: C22.2, U3.7 (CAP1)
unnamed: C20.2, C21.1, R21.2, U3.19 (SRN)
unnamed: C19.2, C20.1, R19.2, U3.18 (SRP)
unnamed: R27.2, TH1.1, U3.6 (TS1)
PACK-: Q2.1 (S), Q2.2 (S), Q2.3 (S), R26.1; also elsewhere on the board
PGND_BAT: C17.2, C18.2, J21.1, R18.1, R19.1, R20.2; also elsewhere on the board
SGND: C19.1, C21.2, C22.1, J22.5, Q1.2 (G), TH1.2, U3.3 (VSS); also elsewhere on the board
VBAT: D5.2 (A), J21.5, R14.1, R22.2; also elsewhere on the board

Notes on the sheet:
MOSFET은 도통되면 Source, Drain 어느 방향으로도 전류의 흐름이 가능 Q1/CHG ON 충전/방전 둘 다 허용 OFF 충전 차단 (과충전) 과방전 조건: UV(셀 저전압)/OCD(방전 과전류)/SCD(단락 보호) 드론의 방전을 차단하면 위험하다 판단해서 뺐음
셀 밸런싱을 위한 셀 전압 측정 및 방전 회로 (소전류)
배터리 최대 연속 전류 = 용량 Ah × C-rate 정상 피크 전류의 20~50% 마진 단락의 경우 2배 마진 Rshunt = Vtrip / Itrip I_OCD = 150A 인 경우 → Rshunt = 75mV / 150A = 0.5mΩ I_SCD = 200A 인 경우 → Rshunt = 100mV / 200A = 0.5mΩ
1. PGND_BAT와 SGND를 분리하고 둘을 0Ω 저항으로 한 점에서 연결한 이유 (Net Tie) - 고전류 리턴 경로와 신호 리턴 경로를 분리 → 전력 GND와 신호 GND를 레이아웃상 분리하여 신호 회로의 흔들림을 방지

Board: 2 copper layers, 86 parts (0 on the bottom side), 40 nets, no tracks yet.
